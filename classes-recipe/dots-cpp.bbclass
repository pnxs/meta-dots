DEPENDS += "dots-cpp dots-dcg-native"

inherit cmake python3native

